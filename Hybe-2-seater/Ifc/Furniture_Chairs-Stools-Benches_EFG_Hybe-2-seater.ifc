Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Furniture_Chairs-Stools-Benches_EFG_Hybe-2-seater.ifc
Time: 2023-02-10T16:30:41
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: Hybe 2 seater
ePset_BIMobjectScript - Armrests: Without armrests; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Hybe 2 seater; SKU (BO_prodsku): Hybe-2-seater; ManufacturName (BO_Manufac): EFG; BrandUrl (BO_brandurl): http://www.efg.se; EditionNumber (BO_edinum): 1; Width (BO_width): 0; Height (BO_height): 0; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/efg/product/Hybe-2-seater; ProductDataUrl (BO_prodaturl): bimobject.com/efg/product/Hybe-2-seater; ProductUrl (BO_producturl): https://www.efg.se/en/product/hybe-hybe-2/; BimObjectMainCategory (BO_bomaincat): Furniture; BimObjectMainCategoryCode (BO_bomaincat_code): furniture; BimObjectCategory (BO_bocat): Chairs, Stools & Benches; BimObjectCategoryCode (BO_bocat_code): chairs-stools-benches; IfcClassification (BO_ifcclas): Furniture; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
